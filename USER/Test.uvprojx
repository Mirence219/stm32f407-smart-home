# Keil uVision project Test.uvprojx, settings and files
target Target 1 (6060000::V6.6::.\ARMCLANG)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Test +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\HARDWARE;..\SYSTEM;..\USER;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\ID;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\Fan;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\BH1750;..\HARDWARE\DHT11;..\HARDWARE\ESP8266;..\HARDWARE\i2c;..\HARDWARE\lock;..\HARDWARE\MQTT;..\HARDWARE\MQTT\MQTTPacket\src;..\HARDWARE\timer;..\HARDWARE\USART3;..\HARDWARE\SteerGear;.\Application;.\Model;.\Controller;.\View;.\View\Pages
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/LCD/: gui.c ili9486.c gui.h ili9486.h font.h pic.h
    ../HARDWARE/fan/: fan.c
    ../HARDWARE/Fan/: fan.h
    ../HARDWARE/LED/: led.c led.h led_gpio.h
    ../HARDWARE/BEEP/: beep.c beep.h
    ../HARDWARE/BH1750/: bh1750.c bh1750.h
    ../HARDWARE/DHT11/: dht11.c dht11.h
    ../HARDWARE/ESP8266/: esp8266.c esp8266.h
    ../HARDWARE/i2c/: i2c.c i2c.h
    ../HARDWARE/lock/: lock.c lock.h
    ../HARDWARE/MQTT/: mqtt_handle.c mqtt_handle.h
    ../HARDWARE/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c MQTTConnect.h MQTTFormat.h MQTTPacket.h MQTTPublish.h MQTTSubscribe.h MQTTUnsubscribe.h StackTrace.h
    ../HARDWARE/USART3/: usart3.c usart3.h
    ../HARDWARE/timer/: Timer.c
    ../HARDWARE/SteerGear/: SteerGear.c SteerGear.h
    ../HARDWARE/usart6/: usart6.c usart6.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group USER
    ./: stm32f4xx_it.c stm32f4xx_it.h stm32f4xx_conf.h main.cpp
  group Application
    ./Application/: application.cpp application.h
  group Model
    ./Model/: attitude_sensor.cpp attitude_sensor.h fingerprint_recognition.cpp fingerprint_recognition.h light_sensor.cpp intelligent_voice.cpp intelligent_voice.h light_sensor.h pressure_sensor.cpp pressure_sensor.h rfbled.cpp rfbled.h rfid.cpp rfid.h smart_door_lock.cpp smart_door_lock.h steering_gear.cpp steering_gear.h temperature_and_humidity_sensor.cpp temperature_and_humidity_sensor.h ultrasonic_sensor.cpp ultrasonic_sensor.h wifi.cpp wifi.h button.cpp button.h buzzer.cpp buzzer.h led.cpp led.h i_model.h i_functional_model.h i_output_model.h i_input_model.h lcd.cpp lcd.h fans.cpp
  group Controller
    ./Controller/: controller.cpp controller.h GuiState.cpp GuiState.h model_data.cpp model_data.h model_snap_shot.cpp model_snap_shot.h i_visitor.h model_visitor.cpp model_visitor.h
  group Model Core
    ./Model/: model.cpp model.h model_manager.cpp model_manager.h
  group View
    ./View/: view.cpp view.h page_painter.cpp page_painter.h widget.cpp widget.h button_widget.h rectangle.h background.h circle.h text.h button_widget.cpp rectangle.cpp background.cpp circle.cpp text.cpp page.h page.cpp
    ./View/Pages/: page1.h page1.cpp page2.h page2.cpp page3.h page3.cpp page4.h page4.cpp debug_page.h debug_page.cpp
software components: Data Exchange:JSON:cJSON 1.7.7
